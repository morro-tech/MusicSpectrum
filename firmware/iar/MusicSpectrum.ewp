# IAR project MusicSpectrum.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\User; ..\lib\CMSIS\Include; ..\lib\CMSIS\STM32F10x\Include; ..\lib\STM32F10x_StdPeriph_Driver\inc; ..\framework; ..\driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MusicSpectrum.hex
  ILINK.IlinkOutputFile: music_spectrum.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group driver
    ../driver/src/: led_matrix.c tty.c
  group framework
    ../framework/: cli.c module.c ringbuffer.c
  group lib/CMSIS
    ../lib/CMSIS/STM32F10x/Source/iar/: startup_stm32f10x_md.s
    ../lib/CMSIS/STM32F10x/Source/: system_stm32f10x.c
  group lib/STM32F1xx_StdPeriph_Driver
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group user
    ../user/: audio_sample.c config.h cr2fft.c main.c platform.c public.c spectrum.c stm32f10x_it.c
  group user/cmd
    ../user/cmd/: cmd_devinfo.c cmd_fft.c
  group user/task
    ../user/task/: cli_task.c
